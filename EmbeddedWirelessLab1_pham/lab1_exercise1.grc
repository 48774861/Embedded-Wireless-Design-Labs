options:
  parameters:
    author: Marc Pham
    generate_options: no_gui
    id: lab1_exercise1
    output_language: python
    run_options: run
    title: Lab 1 - Experiment 1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '500000'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mepham/ECE7377/Lab1/signal_f32_delayed.dat
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/mepham/ECE7377/Lab1/signal_f32_multiplied.dat
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mepham/ECE7377/Lab1/signal_f32.dat
    repeat: 'False'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}

connections:
- [blocks_delay_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0_0, '0', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
