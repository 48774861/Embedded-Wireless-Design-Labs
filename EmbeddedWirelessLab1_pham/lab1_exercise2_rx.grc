options:
  parameters:
    author: Marc Pham
    generate_options: qt_gui
    id: lab1_exercise2
    output_language: python
    title: Lab 1 - Exercise 2
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_chooser
  parameters:
    label: center_frequency
    label0: Channel 1
    label1: Channel 6
    label2: Channel 11
    num_opts: '3'
    option0: '2412000000'
    option1: '2437000000'
    option2: '2462000000'
    type: real
    value: '2412000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3125000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_frequency
    dev_addr: '"addr=10.61.40.174"'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
