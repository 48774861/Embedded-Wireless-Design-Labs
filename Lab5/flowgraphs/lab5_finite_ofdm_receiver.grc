options:
  parameters:
    author: ECE 5377/7377
    category: '[ECE 5377/7377]'
    description: Lab 5 finite raw and squelched OFDM receiver
    gen_cmake: 'Off'
    generate_options: no_gui
    id: lab5_finite_ofdm_receiver
    output_language: python
    run_options: run
    title: 'Lab 5: N310 to Raw and Squelched OFDM File Sinks'
  states: {bus_structure: 'null'}

blocks:
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {bus_structure: 'null'}
- name: lab_root
  id: variable
  parameters:
    value: os.environ.get('ECE7377_LAB5_ROOT', os.path.expanduser('~/ECE7377/labs/lab5'))
  states: {bus_structure: 'null'}
- name: work_dir
  id: variable
  parameters:
    value: os.path.join(lab_root, 'work')
  states: {bus_structure: 'null'}
- name: rx_device_args
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_DEVICE_ARGS', 'addr=127.0.0.1')
  states: {bus_structure: 'null'}
- name: rx_subdevice
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_SUBDEVICE', 'A:0')
  states: {bus_structure: 'null'}
- name: rx_antenna
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_ANTENNA', 'TX/RX')
  states: {bus_structure: 'null'}
- name: samp_rate
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_SAMPLE_RATE', '1e6'))
  states: {bus_structure: 'null'}
- name: center_frequency
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_CENTER_FREQUENCY', '2.45e9'))
  states: {bus_structure: 'null'}
- name: rx_gain
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_RX_GAIN', '60'))
  states: {bus_structure: 'null'}
- name: capture_seconds
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_CAPTURE_SECONDS', '15.0'))
  states: {bus_structure: 'null'}
- name: capture_samples
  id: variable
  parameters:
    value: int(round(samp_rate * capture_seconds))
  states: {bus_structure: 'null'}
- name: output_file
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_OUTPUT_FILE', os.path.join(work_dir, 'captures/lab5_ofdm_tx45_c64.dat'))
  states: {bus_structure: 'null'}
- name: squelched_file
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_SQUELCHED_FILE', os.path.join(work_dir, 'captures/lab5_inspection_squelched_c64.dat'))
  states: {bus_structure: 'null'}
- name: squelch_threshold_db
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_SQUELCH_THRESHOLD_DB', '-78'))
  states: {bus_structure: 'null'}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_antenna
    center_freq0: center_frequency
    clock_rate: 125e6
    clock_source0: internal
    dev_addr: rx_device_args
    dev_args: '""'
    gain0: rx_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: rx_subdevice
    stream_chans: '[0]'
    sync: none
    time_source0: internal
    type: fc32
  states: {bus_structure: 'null'}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {bus_structure: 'null'}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_file
    type: complex
  states: {bus_structure: 'null'}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.01'
    threshold: squelch_threshold_db
  states: {bus_structure: 'null'}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: squelched_file
    type: complex
  states: {bus_structure: 'null'}

connections:
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', analog_simple_squelch_cc_0, '0']
- [analog_simple_squelch_cc_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
