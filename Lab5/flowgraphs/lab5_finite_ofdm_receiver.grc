options:
  parameters:
    author: ECE 7377
    category: '[ECE 5377/7377]'
    description: Lab 5 finite raw and squelched OFDM receiver
    gen_cmake: 'Off'
    generate_options: no_gui
    id: lab5_finite_ofdm_receiver
    output_language: python
    run_options: run
    title: 'Lab 5: N310 to Raw and Squelched OFDM File Sinks'
  states: {}

blocks:
- name: capture_samples
  id: variable
  parameters:
    value: int(round(samp_rate * capture_seconds))
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_CAPTURE_SECONDS', '15'))
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_CENTER_FREQUENCY', '2.45e9'))
  states: {}
- name: lab_root
  id: variable
  parameters:
    value: os.environ.get('ECE7377_LAB5_ROOT', os.path.expanduser('~/ECE7377/Lab5'))
  states: {}
- name: output_file
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_OUTPUT_FILE', os.path.join(work_dir, 'captures/lab5_ofdm_tx50_c64.dat'))
  states: {}
- name: rx_antenna
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_ANTENNA', 'TX/RX')
  states: {}
- name: rx_device_args
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_DEVICE_ARGS', 'addr=10.61.40.174')
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_RX_GAIN', '60'))
  states: {}
- name: rx_subdevice
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_SUBDEVICE', 'A:0')
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_SAMPLE_RATE', '1e6'))
  states: {}
- name: squelch_threshold_db
  id: variable
  parameters:
    value: float(os.environ.get('ECE7377_SQUELCH_THRESHOLD_DB', '-78'))
  states: {}
- name: squelched_file
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_SQUELCHED_FILE', os.path.join(work_dir, 'captures/lab5_inspection_squelched_c64.dat'))
  states: {}
- name: work_dir
  id: variable
  parameters:
    value: os.path.join(lab_root, 'work')
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.01'
    threshold: squelch_threshold_db
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_file
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: squelched_file
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_antenna
    center_freq0: center_frequency
    clock_rate: 125e6
    clock_source0: internal
    dev_addr: rx_device_args
    dev_args: '""'
    gain0: rx_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: rx_subdevice
    stream_chans: '[0]'
    sync: none
    time_source0: internal
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', blocks_file_sink_1, '0']
- [blocks_head_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
