options:
  parameters:
    generate_options: no_gui
    id: Lab2_Task3_rx
    output_language: python
    run_options: run
    title: Lab2_Task3_rx
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: int(T*samp_rate)
  states: {}
- name: RX_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: T
  id: variable
  parameters:
    value: '8'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2450000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mepham/ECE7377/Lab2/work/task3_gain50_c64.dat
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: N
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    clock_rate: 125.0e6
    dev_addr: '"addr=10.61.40.110"'
    gain0: RX_gain
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
