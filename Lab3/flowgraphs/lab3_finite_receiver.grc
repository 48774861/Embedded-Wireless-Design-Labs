options:
  parameters:
    author: ECE 5377/7377
    category: '[ECE 5377/7377]'
    description: Lab 3 finite complex64 receiver
    gen_cmake: 'Off'
    generate_options: no_gui
    id: lab3_finite_receiver
    output_language: python
    run_options: run
    title: 'Lab 3: N310 to Finite File Sink'
  states: {}

blocks:
- name: capture_samples
  id: variable
  parameters:
    value: int(round(samp_rate * capture_seconds))
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: Use 1.0 s for the noise record and 8.0 s for signal records. Set in GRC or with ECE7377_CAPTURE_SECONDS.
    value: float(os.environ.get('ECE7377_CAPTURE_SECONDS', '8.0'))
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: lab_root
  id: variable
  parameters:
    value: os.environ.get('ECE7377_LAB3_ROOT', os.path.expanduser('~/ECE7377'))
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Use a unique filename for every capture.
    value: os.environ.get('ECE7377_OUTPUT_FILE', os.path.join(work_dir, 'captures/task4_tone_c64.dat'))
  states: {}
- name: rx_antenna
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_ANTENNA', 'RX2')
  states: {}
- name: rx_device_args
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_DEVICE_ARGS', 'addr=10.61.40.174')
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Set in GRC or with ECE7377_RX_GAIN_DB.
    value: float(os.environ.get('ECE7377_RX_GAIN_DB', '60'))
  states: {}
- name: rx_subdevice
  id: variable
  parameters:
    value: os.environ.get('ECE7377_RX_SUBDEVICE', 'A:0')
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.25e6
  states: {}
- name: work_dir
  id: variable
  parameters:
    value: os.path.join(lab_root, 'work')
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_file
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: capture_samples
    type: complex
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_antenna
    center_freq0: center_frequency
    clock_rate: 125e6
    clock_source0: internal
    dev_addr: rx_device_args
    dev_args: '""'
    gain0: rx_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: rx_subdevice
    stream_chans: '[0]'
    sync: none
    time_source0: internal
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
