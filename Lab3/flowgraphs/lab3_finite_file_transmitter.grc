options:
  parameters:
    author: ECE 5377/7377
    category: '[ECE 5377/7377]'
    description: Lab 3 finite complex64 waveform transmitter
    gen_cmake: 'Off'
    generate_options: no_gui
    id: lab3_finite_file_transmitter
    output_language: python
    run_options: run
    title: 'Lab 3: Finite File Source to N310'
  states: {bus_structure: 'null'}

blocks:
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {bus_structure: 'null'}
- name: lab_root
  id: variable
  parameters:
    value: os.environ.get('ECE7377_LAB3_ROOT', os.path.expanduser('~/ECE7377/labs/lab3'))
  states: {bus_structure: 'null'}
- name: tx_device_args
  id: variable
  parameters:
    value: os.environ.get('ECE7377_TX_DEVICE_ARGS', 'addr=127.0.0.1')
  states: {bus_structure: 'null'}
- name: tx_subdevice
  id: variable
  parameters:
    value: os.environ.get('ECE7377_TX_SUBDEVICE', 'A:0')
  states: {bus_structure: 'null'}
- name: tx_antenna
  id: variable
  parameters:
    value: os.environ.get('ECE7377_TX_ANTENNA', 'TX/RX')
  states: {bus_structure: 'null'}
- name: samp_rate
  id: variable
  parameters:
    value: 1.25e6
  states: {bus_structure: 'null'}
- name: center_frequency
  id: variable
  parameters:
    value: 2.45e9
  states: {bus_structure: 'null'}
- name: tx_gain
  id: variable
  parameters:
    comment: Set in GRC or with ECE7377_TX_GAIN_DB.
    value: float(os.environ.get('ECE7377_TX_GAIN_DB', '10'))
  states: {bus_structure: 'null'}
- name: tx_file
  id: variable
  parameters:
    comment: Set in GRC or with ECE7377_TX_FILE.
    value: os.environ.get('ECE7377_TX_FILE', os.path.join(lab_root, 'work/waveforms/task3_m4_tx_c64.dat'))
  states: {bus_structure: 'null'}
- name: transmit_seconds
  id: variable
  parameters:
    comment: Finite on-air duration. Start TX first, then run the 8 s RX capture. Set in GRC or with ECE7377_TX_SECONDS.
    value: float(os.environ.get('ECE7377_TX_SECONDS', '20.0'))
  states: {bus_structure: 'null'}
- name: transmit_samples
  id: variable
  parameters:
    comment: Head length keeps the repeated File Source finite.
    value: int(round(samp_rate * transmit_seconds))
  states: {bus_structure: 'null'}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: tx_file
    repeat: 'True'
    type: complex
  states: {bus_structure: 'null'}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: transmit_samples
    type: complex
  states: {bus_structure: 'null'}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_antenna
    center_freq0: center_frequency
    clock_rate: 125e6
    clock_source0: internal
    dev_addr: tx_device_args
    dev_args: '""'
    gain0: tx_gain
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: tx_subdevice
    stream_chans: '[0]'
    sync: none
    time_source0: internal
    type: fc32
  states: {bus_structure: 'null'}

connections:
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
